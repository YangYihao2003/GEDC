# Keil uVision project GD32H759I_START.uvprojx, settings and files
target GD32H759_NN_Invoke (6220000::V6.22::ARMCLANG)
  device: GD32H759II GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.4.0
  cpu: IRAM(0x24000000,0x000E0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x0200000) XRAM(0x20000000,0x00010000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: GD32H759 +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32H7XX
  c include: ..\;..\Firmwares\GD32H7xx_standard_peripheral\Include;..\Firmwares\CMSIS\GD\GD32H7xx\Include;..\Utilities;..\Middlewares\AI\inc;..\Middlewares\AI\inc\operators\;..\Middlewares\AI\inc\operators\cmsis_nn;..\Middlewares\AI\inc\operators\f32;..\Middlewares\AI;..\Core\Include;..\Middlewares\AI\inc\operators\third_party;..\freeRTOS;..\freeRTOS\include;..\freeRTOS\port
  asm define: GD32H759I_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xf0000
  memory RVCT10: RAM 0x0 size 0x10000
  group Application
    ../Core/Source/: gd32h7xx_it.c systick.c main.c nn_model_configure.c nn_model_report.c nn_usart.c ringbuffer.c
  group CMSIS
    ../Firmwares/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group GD32H7xx_Peripherals
    ../Firmwares/GD32H7xx_standard_peripheral/Source/: gd32h7xx_adc.c gd32h7xx_can.c gd32h7xx_cau.c gd32h7xx_cau_aes.c gd32h7xx_cau_des.c gd32h7xx_cau_tdes.c gd32h7xx_cmp.c gd32h7xx_cpdm.c gd32h7xx_crc.c gd32h7xx_ctc.c gd32h7xx_dac.c gd32h7xx_dbg.c gd32h7xx_dci.c gd32h7xx_dma.c gd32h7xx_edout.c gd32h7xx_efuse.c gd32h7xx_enet.c gd32h7xx_exmc.c gd32h7xx_exti.c gd32h7xx_fac.c gd32h7xx_fmc.c gd32h7xx_fwdgt.c gd32h7xx_gpio.c gd32h7xx_hau.c gd32h7xx_hau_sha_md5.c gd32h7xx_hpdf.c gd32h7xx_hwsem.c gd32h7xx_i2c.c gd32h7xx_ipa.c gd32h7xx_lpdts.c gd32h7xx_mdio.c gd32h7xx_mdma.c gd32h7xx_misc.c gd32h7xx_ospi.c gd32h7xx_ospim.c gd32h7xx_pmu.c gd32h7xx_rameccmu.c gd32h7xx_rcu.c gd32h7xx_rspdif.c gd32h7xx_rtc.c gd32h7xx_rtdec.c gd32h7xx_sai.c gd32h7xx_sdio.c gd32h7xx_spi.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_tli.c gd32h7xx_tmu.c gd32h7xx_trigsel.c gd32h7xx_trng.c gd32h7xx_usart.c gd32h7xx_vref.c gd32h7xx_wwdgt.c
  group Startup
    ../Firmwares/CMSIS/GD/GD32H7xx/Source/ARM/: startup_gd32h7xx.s
  group Board
    ../Utilities/: gd32h759i_start.c
  group GD_AI_LIB
    ../Middlewares/AI/: GD_LIB_CM7_v210.lib
  group core
    ../freeRTOS/core/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group port
    ../freeRTOS/port/: port.c
  group heap
    ../freeRTOS/heap/: heap_4.c
software components: CMSIS:CORE 5.2.0
